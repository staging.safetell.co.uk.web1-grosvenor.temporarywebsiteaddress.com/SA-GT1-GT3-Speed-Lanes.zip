Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-10-26T16:22:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190507_1515(x64) - Exporter 17.0.517.0 - Alternate UI 17.15.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 26 16:22:30 2021 * Host: DESKTOP-8K2M230 * Database: C:\Users\DucLN\AppData\Local\Temp\{3B16EA13-6271-4062-8BF7-F282B911703B}\ifc * Database version: 5507 * Database creation date: Tue Oct 26 16:22:28 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 26 16:22:28 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 26 16:22:28 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 3 Lane assembly - 2 x 530 width lane and 1 x 765 width lane, Pedestrian Speed Lane:3 Lane assembly - 2 x 530 width lane and 1 x 765 width lane:370735
In: Level 1
Type - Material: LED_Green, LED_Dark Green, Black, Steel, Glass
Pset_BuildingElementProxyCommon - Reference: 3 Lane assembly - 2 x 530 width lane and 1 x 765 width lane
